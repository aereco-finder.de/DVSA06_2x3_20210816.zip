Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DVSA06_2x3.IFC
Time: 2021-08-16T08:56:03
Written by: SwIFC
Made in: SolidWorks 2018 (Solibri IFC Optimizer)

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: T-0001091^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10400.00050.0007A; Part Number: 10400.00050.0007A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBeam: T-0001097^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 00700.95400.0012A; Part Number: 00700.95400.0012A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBeam: T-0001105^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10200.00200.0009A; Part Number: 10200.00200.0009A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBeam: T-0001109^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10200.08000.0054A; Part Number: 10200.08000.0054A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBeam: T-0001208^B-000469_Kopf (3)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10200.09000.0030A; Part Number: 10200.09000.0030A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBeam: T-0001212^B-000469_Kopf (3)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10400.00030.0003A_M6; Part Number: 10400.00030.0003A_M6; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBeam: T-0001224^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10400.00055.0058A_M6 x 16; Part Number: 10400.00055.0058A_M6 x 16; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBeam: T-0001254^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 00200.95000.0087A_Typenschild DV-A06; Part Number: 00200.95000.0087A_Typenschild DV-A06; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBeam: T-0001255^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 00200.95400.0001A_Warnhinweis; Part Number: 00200.95400.0001A_Warnhinweis; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBeam: T-0001256^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 00200.95400.0014A; Part Number: 00200.95400.0014A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBeam: T-0001261^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 00200.90100.2762A; Part Number: 00200.90100.2762A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBeam: T-0001298^02020.20420.0015C_DSVA06_IFC
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 00200.90100.0336F; Part Number: 00200.90100.0336F; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 16.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBeam: T-0001299^02020.20420.0015C_DSVA06_IFC
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 00200.90100.0334F; Part Number: 00200.90100.0334F; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 16.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBeam: T-0001308^02020.20420.0015C_DSVA06_IFC
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10500.00100.0005A_Ventilatortragblech A5-10; Part Number: 10500.00100.0005A_Ventilatortragblech A5-10; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 16.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBeam: T-0001311^02020.20420.0015C_DSVA06_IFC
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10400.00100.0022A; Part Number: 10400.00100.0022A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 16.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBeam: T-0001314^02020.20420.0015C_DSVA06_IFC
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10400.01000.0002A; Part Number: 10400.01000.0002A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 16.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBeam: T-0001316^02020.20420.0015C_DSVA06_IFC
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10200.08000.0059A; Part Number: 10200.08000.0059A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 16.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBeam: T-0001317^02020.20420.0015C_DSVA06_IFC (2)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10400.00100.0002A; Part Number: 10400.00100.0002A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 16.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: 00200.90100.1586A^00200.90100.0596A_02020.20420.0015C_DSVA06_IFC
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 00200.90100.1586A; Part Number: 00200.90100.1586A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 16.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: 10200.00200.0010A^10200.00100.0099B_B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10200.00200.0010A; Part Number: 10200.00200.0010A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: 10200.08000.0040A_1^10200.08000.0040A_10200.00100.0099B_B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10200.08000.0040A_1; Part Number: 10200.08000.0040A_1; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: 10200.08000.0040A_2^10200.08000.0040A_10200.00100.0099B_B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10200.08000.0040A_2; Part Number: 10200.08000.0040A_2; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: 10200.08000.0040A_3^10200.08000.0040A_10200.00100.0099B_B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10200.08000.0040A_3; Part Number: 10200.08000.0040A_3; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: 10200.08000.0040A_4^10200.08000.0040A_10200.00100.0099B_B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10200.08000.0040A_4; Part Number: 10200.08000.0040A_4; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: CKSHF_03^10200.00200.0002A_10200.00100.0099B_B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: CKSHF_03; Part Number: CKSHF_03; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: CKSHM_03^10200.00200.0003A_B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: CKSHM_03; Part Number: CKSHM_03; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: T-0001207^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10200.08000.0051A; Part Number: 10200.08000.0051A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: T-0001208^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10200.09000.0030A; Part Number: 10200.09000.0030A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: T-0001212^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10400.00030.0003A_M6; Part Number: 10400.00030.0003A_M6; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: T-0001224^B-000469_Kopf (3)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10400.00055.0058A_M6 x 16; Part Number: 10400.00055.0058A_M6 x 16; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: T-0001252^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 00200.90100.1371A; Part Number: 00200.90100.1371A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: T-0001256^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 00200.95400.0014A; Part Number: 00200.95400.0014A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: T-0001257^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 00200.90100.2689A; Part Number: 00200.90100.2689A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: T-0001258^B-000469_Kopf (2)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 00200.90100.0223G; Part Number: 00200.90100.0223G; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: T-0001262^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 00200.90100.2700A; Part Number: 00200.90100.2700A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: T-0001263^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 00200.90100.2039B; Part Number: 00200.90100.2039B; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: T-0001282^B-000469_Kopf (2)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10400.00100.0041A; Part Number: 10400.00100.0041A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: T-0001300^02020.20420.0015C_DSVA06_IFC
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 00200.90100.1397A; Part Number: 00200.90100.1397A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 16.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: T-0001302^02020.20420.0015C_DSVA06_IFC
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 00200.90100.0335F; Part Number: 00200.90100.0335F; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 16.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: T-0001305^02020.20420.0015C_DSVA06_IFC
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 00200.90100.0278B; Part Number: 00200.90100.0278B; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 16.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: T-0001306^02020.20420.0015C_DSVA06_IFC
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10400.00040.0002A_M8; Part Number: 10400.00040.0002A_M8; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 16.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: T-0001311^02020.20420.0015C_DSVA06_IFC
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10400.00100.0022A; Part Number: 10400.00100.0022A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 16.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: T-0001314^02020.20420.0015C_DSVA06_IFC (2)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10400.01000.0002A; Part Number: 10400.01000.0002A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 16.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcBuildingElementProxy: T-0001316^02020.20420.0015C_DSVA06_IFC
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10200.08000.0059A; Part Number: 10200.08000.0059A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 16.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcElementAssembly: 00200.90100.0596A^02020.20420.0015C_DSVA06_IFC
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektleiter: Philipp Kunkel; Erstellt_am: 16.08.2021; Projektnummer: P-00032; Erstellt_von: bf; Kunde: Aereco GmbH; Projektname: Umhausung

# IfcElementAssembly: 02020.20420.0015C^DSVA06_IFC
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.001; Revision: ANY; Source: NOT_KNOWN; Part Number: 02020.20420.0015C; Nomenclature: 02020.20420.0015C; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektleiter: Philipp Kunkel; Erstellt_am: 16.08.2021; Projektnummer: P-00032; Erstellt_von: bf; Kunde: Aereco GmbH; Projektname: Umhausung

# IfcElementAssembly: 10200.00100.0099B^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Bereinigungshinweis: 0.000; Dateityp: 0.000; Projektleiter: 0.000; Erstellt_am: 0.000; Projektnummer: 0.000; Erstellt_von: 0.000; Kunde: 0.000; Projektname: 0.000

# IfcElementAssembly: 10200.00200.0002A^10200.00100.0099B_B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Bereinigungshinweis: 0.000; Dateityp: 0.000; Projektleiter: 0.000; Erstellt_am: 0.000; Projektnummer: 0.000; Erstellt_von: 0.000; Kunde: 0.000; Projektname: 0.000

# IfcElementAssembly: 10200.00200.0003A^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Bereinigungshinweis: 0.000; Dateityp: 0.000; Projektleiter: 0.000; Erstellt_am: 0.000; Projektnummer: 0.000; Erstellt_von: 0.000; Kunde: 0.000; Projektname: 0.000

# IfcElementAssembly: 10200.08000.0040A^10200.00100.0099B_B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Bereinigungshinweis: 0.000; Dateityp: 0.000; Projektleiter: 0.000; Erstellt_am: 0.000; Projektnummer: 0.000; Erstellt_von: 0.000; Kunde: 0.000; Projektname: 0.000

# IfcElementAssembly: B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Bereinigungshinweis: Aus; Dateityp: Einzelteil; Projektnummer: P-00032; Erstellt_von: bf; Kunde: Aereco GmbH; Projektname: Umhausung; Projektleiter: Philipp Kunkel; Erstellt_am: 05.08.2021; Beschreibung: DVS A06; Gewicht des Gerätes (Sockel) kg: 41 (32); Durchmesser Rohranschlussmm: 200; Kanalanschluss-Maße mm: 200 x 200; Maximaler Volumenstrom zur Auslegung (75 %) m3/h: 293; Schalldruckpegel in 3 Meter Entfernung zur Auslegung (75 %) - Lp,A dB(A): 44; Schallleistungspegel an der Saugseite zur Auslegung (75 %) - Lw, A dB(A): 37; Maximaler Volumenstrom (100 %) m3/h: 390; Schalldruckpegel in 3 Meter Entfernung (100 %) - Lp,A dB(A): 48; Schallleistungspegel an der Saugseite (100 %) - Lw, A dB(A): 41; Schalldruckpegel in 3 Meter Entfernung (50 %) - Lp,A dB(A): 41; Schallleistungspegel an der Saugseite (50 %) - Lw, A dB(A): 33; Digitale Druckregelanzeige: standard; Einstellbare Druckerhöhung Pa: 40 - 200; Antriebstechnik: EC-Motor; Anschlussspannung: 230 V / 50 Hz; Maximaler Nennstrom A: 0,75; Leistungsaufnahme zur Auslegung (75 %) W: 28; SFP zur Auslegung (75 %) W/m³/h: 0,096; Maximale Leistungsaufnahme (Motoranlauf) Watt: 87; Maximale Lufttemperatur °C: 40; Schutzart des Motors IP: 54; Motorschutz: intern; Material (Gehäuse): verzinktes Stahlblech, Aluminium (Sockel)

# IfcElementAssembly: DVSA06_2x3
In: Default Storey
SolidWorks Custom Properties - Erstellt_von: bf; Gewicht des Gerätes (Sockel) kg: 41 (32); Bereinigungshinweis: Aus; Dateityp: Einzelteil; Projektnummer: P-00032; Kunde: Aereco GmbH; Projektname: DVSA06; Projektleiter: Philipp Kunkel; Erstellt_am: 05.08.2021; Beschreibung: DVS A06; Durchmesser Rohranschlussmm: 200; Kanalanschluss-Maße mm: 200 x 200; Maximaler Volumenstrom zur Auslegung (75 %) m3/h: 293; Schalldruckpegel in 3 Meter Entfernung zur Auslegung (75 %) - Lp,A dB(A): 44; Schallleistungspegel an der Saugseite zur Auslegung (75 %) - Lw, A dB(A): 37; Maximaler Volumenstrom (100 %) m3/h: 390; Schalldruckpegel in 3 Meter Entfernung (100 %) - Lp,A dB(A): 48; Schallleistungspegel an der Saugseite (100 %) - Lw, A dB(A): 41; Schalldruckpegel in 3 Meter Entfernung (50 %) - Lp,A dB(A): 41; Schallleistungspegel an der Saugseite (50 %) - Lw, A dB(A): 33; Digitale Druckregelanzeige: standard; Einstellbare Druckerhöhung Pa: 40 - 200; Antriebstechnik: EC-Motor; Anschlussspannung: 230 V / 50 Hz; Maximaler Nennstrom A: 0,75; Leistungsaufnahme zur Auslegung (75 %) W: 28; SFP zur Auslegung (75 %) W/m³/h: 0,096; Maximale Leistungsaufnahme (Motoranlauf) Watt: 87; Maximale Lufttemperatur °C: 40; Schutzart des Motors IP: 54; Motorschutz: intern; Material (Gehäuse): verzinktes Stahlblech, Aluminium (Sockel)
PSet_Mass_Property - Mass Measure: 0.00190654; Area Measure: 4.3564 m2; Volume Measure: 0.00190654 m3

# IfcFlowFitting: T-0001304^02020.20420.0015C_DSVA06_IFC
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10400.00030.0025A; Part Number: 10400.00030.0025A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 16.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcFooting: T-0001103^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10200.00100.0087A_2_DV A05-10; Part Number: 10200.00100.0087A_2_DV A05-10; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcFooting: T-0001303^02020.20420.0015C_DSVA06_IFC
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 00700.95400.0012A; Part Number: 00700.95400.0012A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 16.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcFooting: T-0001316^02020.20420.0015C_DSVA06_IFC
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 10200.08000.0059A; Part Number: 10200.08000.0059A; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 16.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH

# IfcMember: T-0001260^B-000469_Kopf
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Nomenclature: 00200.90100.2048D; Part Number: 00200.90100.2048D; Source: NOT_KNOWN; Revision: ANY; Projektnummer: P-00032; Erstellt_am: 05.08.2021; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_von: bf; Projektleiter: Philipp Kunkel; Projektname: Umhausung; Kunde: Aereco GmbH
